# IAR project siglib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: c:\siglib\include; C:\Program Files\IAR Systems\Embedded Workbench 4.0\ARM\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: siglib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: adaptive.c arbfft.c chirpz.c comms.c complex.c complexa.c control.c convolve.c correlat.c datatype.c decint.c delay.c dsputil2.c dsputils.c dtmf.c fdfilter.c ffourier.c filter.c firfilt.c fourier.c icoder.c iirfilt.c image.c matrix.c minmax.c mod_a.c mod_d.c modem.c mux.c prbs.c pspect.c regress.c siggen.c siglib.c smath.c speech.c stats.c timing.c trig.c viterbi.c window.c
