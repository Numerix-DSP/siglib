<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <file>
    <name>$PROJ_DIR$\adaptive.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\arbfft.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\chirpz.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\comms.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\complex.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\complexa.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\control.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\convolve.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\correlat.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\datatype.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\decint.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\delay.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\dsputil2.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\dsputils.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\dtmf.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\fdfilter.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\ffourier.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\filter.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\firfilt.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\fourier.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\icoder.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\iirfilt.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\image.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\matrix.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\minmax.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\mod_a.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\mod_d.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\modem.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\mux.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\prbs.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pspect.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\regress.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\siggen.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\siglib.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\smath.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\speech.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stats.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\timing.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\trig.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\viterbi.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\window.c</name>
  </file>
</project>


